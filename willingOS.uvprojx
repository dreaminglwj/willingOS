# Keil uVision project willingOS.uvprojx, settings and files
target willingOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: willingOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\core;.\core\sys;.\include;.\core\port\cpus\ARM_Cotex_M3;.\core\cpu\ARM-Cortex-M3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group core
    ./core/task/: task.c
    ./core/sys/: systick.c sysTick.h willingOS.c willingOS.h
  group include
    ./include/: memory.h protable.h task.h willing.h WillingOSConfig.h
  group user
    ./user/: main.c stm32f10x_it.c
  group port
    ./core/port/cpus/ARM_Cotex_M3/: coreDef.h port.c
    ./core/port/memory/: memory.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
